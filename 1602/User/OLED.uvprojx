# Keil uVision project OLED.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: OLED
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX,ARDUCAM_SN9C2285
  c include: ..\CORE;..\I2CBUS;..\STM32F03x_FWLib\inc;..\SYSTEM;..\User;..\HARDWARE\ARDUCAM;..\HARDWARE\1602;..\HARDWARE\PWM
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CORE
    ../CORE/: startup_stm32f0xx.s
    ./: system_stm32f0xx.c
  group User
    ./: main.c stm32f0xx_it.c
  group STM32F03x_FWLib
    ../STM32F03x_FWLib/src/: stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_flash.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c
  group I2CBUS
    ../I2CBUS/: i2c_bus.c i2c_slave.c
  group HARDWARE
    ../HARDWARE/1602/: bsp_1602.c
    ../HARDWARE/PWM/: PWM.c
